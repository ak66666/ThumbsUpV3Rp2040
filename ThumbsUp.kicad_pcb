# Repository ak66666/ThumbsUpV3Rp2040

File README.md:

# ThumbsUp! v3 RP2040-based 4x12 keyboard for Kailh Choc switches

Multilevel 44 Key Split Contoured Keyboard.
2-key Thumb Cluster

* RP2040 is soldered on the boards.
* TRS (3-wire) audio cable to connect the halves.
* Hot swap sockets for Kailh Choc switches.
* USB-C connectors.
* Connects to computer from either side, halves could be used separately.

Other pictures in Photos folder.

# Firmware

Please refer to this article:
https://thumbsupkeyboards.blogspot.com/2024/02/source-files-and-default-firmware.html

## KiCad design ThumbsUp.kicad_pcb

Parts:
BOOTSEL1, BOOTSEL2: TL1016AAF220QG; Manufacturer_Part_Number TL1016AAF220QG; Mouser Part Number 612-TL1016AAF220QG
C2, C6, C7, C10, C13, C14, C15, C16, C17, C19, C23, C25, C26, C27, C28, C29, C31, C32: 0.1uF; C_0402_1005Metric
C3, C12, C20, C24: 1uF; C_0402_1005Metric
C4, C5, C21, C22: 27pF; C_0402_1005Metric
C8, C9, C11, C18: 10uF; C_0402_1005Metric
F1, F2: Polyfuse; Fuse_1206_3216Metric
IC1, IC3: RP2040; QFN40P700X700X90-57N-D; Manufacturer_Part_Number RP2040
IC2, IC4: W25Q128JVSIM; SOIC127P790X216-8N; Manufacturer_Part_Number W25Q128JVSIM; Mouser Part Number 454-W25Q128JVSIM
J1, J2, J4, J6, J7, J8, J24, J25, J26, J27: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J3, J5, J20, J21, J22, J23, J28, J29, J30, J31: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J9, J11, J13, J15, J17, J19, J34, J38, J40, J42, J44, J47: Raiser_Female; PinSocket_1x04_P2.54mm_Vertical
J10, J12, J14, J16, J18, J33, J35, J39, J41, J43, J45, J48: Raiser_Male; PinHeader_1x04_P2.54mm_Vertical
J32, J37: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J36, J46: STX-3501-3N; STX35013N; Manufacturer_Part_Number STX-3501-3N; Mouser Part Number 806-STX-3501-3N
MX1: SwESC; Kailh_socket_PG1350_optional
MX2: SwTAB; Kailh_socket_PG1350_optional
MX3: SwLCTL; Kailh_socket_PG1350_optional
MX4: SwQ; Kailh_socket_PG1350_optional
MX5: SwA; Kailh_socket_PG1350_optional
MX6: SwZ; Kailh_socket_PG1350_optional
MX7: SwW; Kailh_socket_PG1350_optional
MX8: SwS; Kailh_socket_PG1350_optional
MX9: SwX; Kailh_socket_PG1350_optional
MX10: SwLWIN; Kailh_socket_PG1350_optional
MX11: SwE; Kailh_socket_PG1350_optional
MX12: SwD; Kailh_socket_PG1350_optional
MX13: SwC; Kailh_socket_PG1350_optional
MX14: SwLALT; Kailh_socket_PG1350_optional
MX15: SwR; Kailh_socket_PG1350_optional
MX16: SwF; Kailh_socket_PG1350_optional
MX17: SwV; Kailh_socket_PG1350_optional
MX18: SwLMOD; Kailh_socket_PG1350_optional
MX19: SwT; Kailh_socket_PG1350_optional
MX20: SwG; Kailh_socket_PG1350_optional
MX21: SwB; Kailh_socket_PG1350_optional
MX22: SwLSHFT; Kailh_socket_PG1350_optional
MX23: SwY; Kailh_socket_PG1350_optional
MX24: SwH; Kailh_socket_PG1350_optional
MX25: SwN; Kailh_socket_PG1350_optional
MX26: SwRSHFT; Kailh_socket_PG1350_optional
MX27: SwU; Kailh_socket_PG1350_optional
MX28: SwJ; Kailh_socket_PG1350_optional
MX29: SwM; Kailh_socket_PG1350_optional
MX30: SwRMOD; Kailh_socket_PG1350_optional
MX31: SwI; Kailh_socket_PG1350_optional
MX32: SwK; Kailh_socket_PG1350_optional
MX33: SwCOMMA; Kailh_socket_PG1350_optional
MX34: SwRALT; Kailh_socket_PG1350_optional
MX35: SwO; Kailh_socket_PG1350_optional
MX36: SwL; Kailh_socket_PG1350_optional
MX37: SwDOT; Kailh_socket_PG1350_optional
MX38: SwMENU; Kailh_socket_PG1350_optional
MX39: SwP; Kailh_socket_PG1350_optional
MX40: SwCOLON; Kailh_socket_PG1350_optional
MX41: Sw?; Kailh_socket_PG1350_optional
MX42: SwBKSP; Kailh_socket_PG1350_optional
MX43: SwENTER; Kailh_socket_PG1350_optional
MX44: SwRCTRL; Kailh_socket_PG1350_optional
R1, R2, R14, R15: 27.4; R_0402_1005Metric
R3, R12: 10k; R_0402_1005Metric
R4, R5: 5.1K; R_0805_2012Metric
R6, R16: 1k; R_0402_1005Metric
R7, R13: DNF; R_0402_1005Metric
R8, R9, R10, R11: 5.1k; R_0402_1005Metric
RUN1, RUN2: TL1016AAF220QG; Manufacturer_Part_Number TL1016AAF220QG; Mouser Part Number 612-TL1016AAF220QG
U1, U2: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
Y1, Y2: ABLS-12.000MHZ-B4-T; HC%2f49US-(AT49)_1

Connections:
+1V1: C12.1, C13.1, C14.1, C24.1, C26.1, C28.1, IC1.23 (DVDD_1), IC1.45 (VREG_VOUT), IC1.50 (DVDD_2), IC3.23 (DVDD_1), IC3.45 (VREG_VOUT), IC3.50 (DVDD_2)
+3V3: C2.1, C3.1, C6.1, C7.1, C10.1, C11.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C23.1, C25.1, C27.1, C29.1, C31.1, C32.1, IC1.1 (IOVDD_1), IC1.10 (IOVDD_2), IC1.22 (IOVDD_3), IC1.33 (IOVDD_4), IC1.42 (IOVDD_5), IC1.43 (ADC_AVDD), IC1.44 (VREG_VIN), IC1.48 (USB_VDD), IC1.49 (IOVDD_6), IC2.8 (VCC), IC3.1 (IOVDD_1), IC3.10 (IOVDD_2), IC3.22 (IOVDD_3), IC3.33 (IOVDD_4), IC3.42 (IOVDD_5), IC3.43 (ADC_AVDD), IC3.44 (VREG_VIN), IC3.48 (USB_VDD), IC3.49 (IOVDD_6), IC4.8 (VCC), R4.1, R5.2, R7.2, R13.2, U1.2 (VO), U2.2 (VO); also elsewhere on the board
D+: J32.A6 (D+), J32.B6 (D+), R2.2
D-: J32.A7 (D-), J32.B7 (D-), R1.2
K_A: IC1.38 (GPIO26/ADC0), J16.2
K_B: IC1.14 (GPIO11), MX21.2 (ROW)
K_BSPC: IC3.34 (GPIO22), J43.1
K_COMM: IC3.18 (GPIO15), J27.1
K_D: IC1.36 (GPIO24), J16.4
K_DOT: IC3.17 (GPIO14), J27.2
K_E: IC1.15 (GPIO12), J45.4
K_ENT: IC3.38 (GPIO26/ADC0), J12.4
K_ESC: IC1.18 (GPIO15), J45.1
K_F: IC1.11 (GPIO8), MX16.2 (ROW)
K_G: IC1.13 (GPIO10), MX20.2 (ROW)
K_H: IC3.5 (GPIO3), MX24.2 (ROW)
K_I: IC3.4 (GPIO2), J43.4
K_J: IC3.9 (GPIO7), MX28.2 (ROW)
K_K: IC3.41 (GPIO29/ADC3), J12.1
K_L: IC3.40 (GPIO28/ADC2), J12.2
K_LALT: IC1.3 (GPIO1), MX14.2 (ROW)
K_LCTL: IC1.5 (GPIO3), J8.1
K_LSFT: IC1.41 (GPIO29/ADC3), J3.2
K_LWR: IC3.36 (GPIO24), J5.2
K_M: IC3.8 (GPIO6), MX29.2 (ROW)
K_MNU: IC3.31 (GPIO20), MX38.2 (ROW)
K_N: IC3.7 (GPIO5), MX25.2 (ROW)
K_O: IC3.3 (GPIO1), J43.3
K_P: IC3.2 (GPIO0), J43.2
K_Q: IC1.17 (GPIO14), J45.2
K_R: IC1.9 (GPIO7), MX15.2 (ROW)
K_RALT: IC3.30 (GPIO19), MX34.2 (ROW)
K_RCTL: IC3.15 (GPIO12), J27.4
K_RSE: IC1.40 (GPIO28/ADC2), J3.4
K_RSFT: IC3.37 (GPIO25), J5.3
K_S: IC1.37 (GPIO25), J16.3
K_SEMICOL: IC3.39 (GPIO27/ADC1), J12.3
K_SLASH: IC3.16 (GPIO13), J27.3
K_T: IC1.12 (GPIO9), MX19.2 (ROW)
K_TAB: IC1.39 (GPIO27/ADC1), J16.1
K_U: IC3.11 (GPIO8), MX27.2 (ROW)
K_W: IC1.16 (GPIO13), J45.3
K_WIN: IC1.2 (GPIO0), MX10.2 (ROW)
K_X: IC1.7 (GPIO5), J8.3
K_Y: IC3.6 (GPIO4), MX23.2 (ROW)
K_Z: IC1.6 (GPIO4), J8.2
L-BASE: BOOTSEL1.3, BOOTSEL1.4, BOOTSEL2.3, BOOTSEL2.4, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C31.2, C32.2, IC1.19 (TESTEN), IC1.57 (GND), IC2.4 (GND), IC3.19 (TESTEN), IC3.29 (GPIO18), IC3.57 (GND), IC4.4 (GND), J2.4, J3.1, J5.4, J9.4, J19.4, J25.4, J32.A1 (GND), J32.A12 (GND), J32.B1 (GND), J32.B12 (GND), J32.S1 (SHIELD), J36.1, J37.A1 (GND), J37.A12 (GND), J37.B1 (GND), J37.B12 (GND), J37.S1 (SHIELD), J46.1, MX10.1 (COL), MX14.1 (COL), MX15.1 (COL), MX16.1 (COL), MX17.1 (COL), MX19.1 (COL), MX20.1 (COL), MX21.1 (COL), MX23.1 (COL), MX24.1 (COL), MX25.1 (COL), MX27.1 (COL), MX28.1 (COL), MX29.1 (COL), MX34.1 (COL), MX38.1 (COL), R8.2, R9.1, R10.2, R11.1, RUN1.3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
L-RING1: C8.1, C9.1, F1.1, F2.1, J36.3, J46.3, U1.3 (VI), U2.3 (VI)
L-TIP: IC1.32 (GPIO21), J36.2, R4.2
unnamed: BOOTSEL1.1, BOOTSEL1.2, R3.1
unnamed: BOOTSEL2.1, BOOTSEL2.2, R12.1
unnamed: C5.1, R6.2, Y1.1
unnamed: C22.1, R16.2, Y2.1
unnamed: IC1.26 (RUN), RUN1.1, RUN1.2
unnamed 58: IC1.29 (GPIO18); also elsewhere on the board
unnamed: IC1.46 (USB_DM), R1.1
unnamed: IC1.47 (USB_DP), R2.1
unnamed: IC3.26 (RUN), RUN2.1, RUN2.2
unnamed: IC3.46 (USB_DM), R15.1
unnamed: IC3.47 (USB_DP), R14.1
unnamed: J4.1, MX18.1 (COL), MX22.1 (COL)
unnamed: J4.2, MX22.2 (ROW)
unnamed: J4.4, MX18.2 (ROW)
unnamed: J6.2, MX30.2 (ROW)
unnamed: J6.3, MX26.2 (ROW)
unnamed: J6.4, MX26.1 (COL), MX30.1 (COL)
unnamed: J11.1, MX32.2 (ROW)
unnamed: J11.2, MX36.2 (ROW)
unnamed: J11.3, MX40.2 (ROW)
unnamed: J11.4, MX43.2 (ROW)
unnamed: J15.1, MX2.2 (ROW)
unnamed: J15.2, MX5.2 (ROW)
unnamed: J15.3, MX8.2 (ROW)
unnamed: J15.4, MX12.2 (ROW)
unnamed: J21.4, MX1.1 (COL), MX2.1 (COL), MX3.1 (COL), MX4.1 (COL), MX5.1 (COL), MX6.1 (COL), MX7.1 (COL), MX8.1 (COL), MX9.1 (COL), MX11.1 (COL), MX12.1 (COL), MX13.1 (COL)
unnamed: J23.1, MX3.2 (ROW)
unnamed: J23.2, MX6.2 (ROW)
unnamed: J23.3, MX9.2 (ROW)
unnamed: J23.4, MX13.2 (ROW)
unnamed: J29.4, MX31.1 (COL), MX32.1 (COL), MX33.1 (COL), MX35.1 (COL), MX36.1 (COL), MX37.1 (COL), MX39.1 (COL), MX40.1 (COL), MX41.1 (COL), MX42.1 (COL), MX43.1 (COL), MX44.1 (COL)
unnamed: J31.1, MX33.2 (ROW)
unnamed: J31.2, MX37.2 (ROW)
unnamed: J31.3, MX41.2 (ROW)
unnamed: J31.4, MX44.2 (ROW)
unnamed: J32.A5 (CC1), R8.1
unnamed: J32.B5 (CC2), R9.2
unnamed: J37.A5 (CC1), R10.1
unnamed: J37.B5 (CC2), R11.2
unnamed: J42.1, MX42.2 (ROW)
unnamed: J42.2, MX39.2 (ROW)
unnamed: J42.3, MX35.2 (ROW)
unnamed: J42.4, MX31.2 (ROW)
unnamed: J44.1, MX1.2 (ROW)
unnamed: J44.2, MX4.2 (ROW)
unnamed: J44.3, MX7.2 (ROW)
unnamed: J44.4, MX11.2 (ROW)
QSPI_SCLK: IC1.52 (QSPI_SCLK), IC2.6 (CLK)
QSPI_SD0: IC1.53 (QSPI_SD0), IC2.5 (DI_(IO0))
QSPI_SD1: IC1.55 (QSPI_SD1), IC2.2 (DO_(IO1))
QSPI_SD2: IC1.54 (QSPI_SD2), IC2.3 (~WP_(IO2))
QSPI_SD3: IC1.51 (QSPI_SD3), IC2.7 (~HOLD_OR_~/RESET_(IO3))
QSPI_SSN: IC1.56 (QSPI_SS_N), IC2.1 (~CS), R3.2, R7.1
R-TIP: IC3.32 (GPIO21), J46.2, R5.1
RD+: J37.A6 (D+), J37.B6 (D+), R14.2
RD-: J37.A7 (D-), J37.B7 (D-), R15.2
RQSPI_SCLK: IC3.52 (QSPI_SCLK), IC4.6 (CLK)
RQSPI_SD0: IC3.53 (QSPI_SD0), IC4.5 (DI_(IO0))
RQSPI_SD1: IC3.55 (QSPI_SD1), IC4.2 (DO_(IO1))
RQSPI_SD2: IC3.54 (QSPI_SD2), IC4.3 (~WP_(IO2))
RQSPI_SD3: IC3.51 (QSPI_SD3), IC4.7 (~HOLD_OR_~/RESET_(IO3))
RQSPI_SSN: IC3.56 (QSPI_SS_N), IC4.1 (~CS), R12.2, R13.1
RXIN: C21.1, IC3.20 (XIN), Y2.2
RXOUT: IC3.21 (XOUT), R16.1
XIN: C4.1, IC1.20 (XIN), Y1.2
XOUT: IC1.21 (XOUT), R6.1

Notes on the sheet:
As in Planck/rev4: #define MATRIX_ROW_PINS { D3, D5, B5, B6 } #define MATRIX_COL_PINS { F1, F0, B0, C7, F4, F5, F6, F7, D4, D6, B4, D7 } #define DIODE_DIRECTION COL2ROW

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
Board: 2 copper layers, 247.3 x 260.9 mm, 153 parts (87 on the bottom side), 118 nets.

Other parts of the board:
R17: 5.1K; R_0402_1005Metric

Their connections:
+3V3: R17.1; also elsewhere on the board
unnamed 58: R17.2; also elsewhere on the board

## Commit log

2022-12-25 Initial layout of v3 created
2022-12-26 Prepared the boards to be split
2022-12-26 Added audio connector
2022-12-26 Rearranged the header pins to match the actual positions.
2022-12-26 Reviewed the basic layout
2022-12-26 Traced the top and bottom plates.
2022-12-26 Retracing the plates.
2022-12-27 Tracing the plates.
2022-12-30 Somewhat finished the PCB tracing
2023-01-01 Added a missing line SS-N
2023-01-08 Added mounting holes, silkscreens
2023-01-09 Generated Gerbers, no assebly files yet
2023-01-09 Added BOM, fixed the placement files
2023-01-22 Fixed the missing connectors and handiness pins
2023-01-28 Gerbers regenerated for L2, R2
2023-01-28 Updated BOM, POS files
2023-01-29 Updated the readme file.
2025-02-27 ThumbsUp v3: Updated description.
